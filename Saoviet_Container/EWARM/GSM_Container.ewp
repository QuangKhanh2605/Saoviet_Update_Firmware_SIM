# IAR project GSM_Container.ewp, settings and files
configuration GSM_Container (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151RC ST STM32L151RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xC; DEVICE_TYPE_GATEWAY
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_common; ..\user_app\user_app_sim; ..\user_app\user_at_serial; ..\user_app\user_log; ..\user_app\user_uart; ..\user_component\mqtt_lib\inc; ..\user_component\user_sim; ..\user_component\user_sim\user_ec200u; ..\user_eventdriven; ..\user_queue; ..\user_timer; ..\user_util; ..\user_app\user_app_inverter; ..\user_app\user_app_mem; ..\user_component\user_mem; ..\user_component\user_mem\user_external_eeprom; ..\user_component\user_mem\user_external_eeprom\user_cat24; ..\user_component\user_mem\user_external_flash; ..\user_component\user_mem\user_external_flash\external_flash_S25FL216K; ..\user_component\user_mem\user_internal_mem; ..\user_app\user_app_update
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GSM_Container.bin
  ILINK.IlinkOutputFile: GSM_Container.out
  ILINK.IlinkIcfFile: stm32l151xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xc.s
  group Application/User/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Application/User/Core
    ../Core/Src/: adc.c gpio.c i2c.c main.c rtc.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c usart.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group user_app/user_app_comm
    ../user_app/user_app_common/: user_app_comm.c user_app_comm.h user_define.h user_modem.c user_modem.h user_modem_init.c user_modem_init.h
  group user_app/user_app_inverter
    ../user_app/user_app_inverter/: user_app_inverter.c user_app_inverter.h user_sv_inverter.h
  group user_app/user_app_mem
    ../user_app/user_app_mem/: user_app_mem.c user_app_mem.h
    ../user_app/user_app_sim/: user_app_sim.c
  group user_app/user_app_sim
    ../user_app/user_app_sim/: user_app_sim.h user_mqtt.c user_mqtt.h
  group user_app/user_app_update
    ../user_app/user_app_update/: user_app_update.c user_app_update.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_log
    ../user_app/user_log/: user_log.c user_log.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component/mqtt_lib
    ../user_component/mqtt_lib/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group user_component/user_memory
    ../user_component/user_mem/: user_mem_comm.h
  group user_component/user_memory/user_external_eeprom
    ../user_component/user_mem/user_external_eeprom/: user_external_eeprom.c user_external_eeprom.h
  group user_component/user_memory/user_external_eeprom/user_cat24
    ../user_component/user_mem/user_external_eeprom/user_cat24/: cat24mxx.c cat24mxx.h
  group user_component/user_memory/user_external_flash
    ../user_component/user_mem/user_external_flash/: user_external_flash.c user_external_flash.h
  group user_component/user_memory/user_external_flash/user_eflash_S25FL216K
    ../user_component/user_mem/user_external_flash/external_flash_S25FL216K/: S25FL216K.c S25FL216K.h
  group user_component/user_memory/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_component/user_sim
    ../user_component/user_sim/: user_sim.c user_sim.h user_sim_common.c user_sim_common.h
  group user_component/user_sim/user_ec200u
    ../user_component/user_sim/user_ec200u/: user_ec200u.c user_ec200u.h
  group user_event_driven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_adc.c user_adc.h user_lpm.c user_lpm.h user_modbus_rtu.c user_modbus_rtu.h user_obis_sv.c user_obis_sv.h user_string.c user_string.h user_time.c user_time.h user_util.c user_util.h
